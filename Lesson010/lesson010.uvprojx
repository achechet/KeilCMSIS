# Keil uVision project lesson010.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson010
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\ds18b20;.\TimerTIM6
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group ds18b20
    ./ds18b20/: ds18b20.c ds18b20.h
  group TimerTIM6
    ./TimerTIM6/: tim6.c tim6.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
